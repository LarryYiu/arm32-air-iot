# Keil uVision project arm32-air-iot.uvprojx, settings and files
target ARM32 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: GD32F303ZE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.5.0
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: arm32-air-iot
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\App;.\Arm_kernel;.\Driver;.\GD32_lib;.\GD32_lib\Include
  asm include: .\App;.\Arm_kernel;.\Driver;.\GD32_lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ./App/: main.c
  group Arm_kernel
    ./Arm_kernel/: system_gd32f30x.c startup_gd32f30x_hd.s
