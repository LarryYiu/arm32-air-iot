# Keil uVision project ARM.uvprojx, settings and files
target ARM (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: GD32F303RE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.5.0
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ARM +hex
  AfterMake: fromelf --text -a -c --output .\Objects\ARM.dis .\Objects\ARM.axf
  AfterMake: fromelf --bin -a -c --output .\Objects\ARM.bin .\Objects\ARM.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\App;.\Arm_kernel;.\Gd32_Lib;.\Gd32_Lib\Include;.\Driver;.\Rtt_Segger;.\Protocol
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ./App/: main.c wifi_app.c storage_app.c
  group Driver
    ./Driver/: systick.c gpio_decoder.c dwt_delay.c key_driver.c led_driver.c sht20_driver.c hk_a5_driver.c uart.c battery_lvl.c rtc.c esp8684_driver.c internal_flash.c app_driver.c
  group Arm_kernel
    ./Arm_kernel/: startup_gd32f30x_hd.s system_gd32f30x.c
  group Gd32_Lib
    ./Gd32_Lib/Source/: gd32f30x_gpio.c gd32f30x_rcu.c gd32f30x_dma.c gd32f30x_usart.c gd32f30x_misc.c gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_rtc.c gd32f30x_pmu.c gd32f30x_fmc.c
  group Rtt_Segger
    ./Rtt_Segger/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Protocol
    ./Protocol/: at.c
